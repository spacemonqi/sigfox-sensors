# Keil uVision project SigFox_PushButton_Project.uvprojx, settings and files
target IDB007 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x28000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_IDB007 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH BLUENRG1_DEVICE NO_BLE_STACK DEBUG_BLE_NO ERASE_VALUE_IS_FF IDB00xV2 USE_FLASH
  c misc: --diag_suppress=951 --wchar32
  c include: ..\..\inc;..\..\..\..\..\Drivers\MCU\HAL_BLUENRG\inc;..\..\..\..\..\Drivers\MCU\CMSIS\BlueNRG1\inc;..\..\..\..\..\Drivers\MCU\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Drivers\BSP\SDK_Eval_BlueNRG\inc;..\..\..\..\..\Drivers\S2LP_Middleware\BlueNRG\inc;..\..\..\..\..\Drivers\Utils\BlueNRG\inc;..\..\..\Sigfox_Libs\inc;..\..\..\ST_API\inc;..\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --no_strict_wchar_size
  group Drivers\BlueNRG_Drivers
    ../../../../../Drivers/MCU/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Drivers\HAL
    ../../../../../Drivers/MCU/HAL_BLUENRG/src/: clock.c gp_timer.c miscutil.c osal.c sleep.c context_switch.s
  group Drivers\BSP
    ../../../../../Drivers/BSP/SDK_Eval_BlueNRG/src/: SDK_EVAL_Button.c SDK_EVAL_Led.c
  group Drivers\CMSIS
    ../../../../../Drivers/MCU/CMSIS/BlueNRG1/src/: system_bluenrg1.c
  group Drivers\Utils
    ../../../../../Drivers/Utils/BlueNRG/src/: SDK_UTILS_Flash.c SDK_UTILS_Timers.c
  group S2LP_Middleware\S2LP_AUX
    ../../../../../Drivers/S2LP_Middleware/BlueNRG/src/: S2LP_AUX_EEPROM.c S2LP_AUX_Utils.c
    ../../../../../Drivers/S2LP_Middleware/BlueNRG/src/TCXO/: S2LP_AUX_TCXO_AUTO.c S2LP_AUX_TCXO_NO.c
    ../../../../../Drivers/S2LP_Middleware/BlueNRG/src/FEM/: S2LP_AUX_FEM_AUTO.c S2LP_AUX_FEM_MonarchRefDesign.c S2LP_AUX_FEM_NO.c
  group S2LP_Middleware\S2LP_CORE
    ../../../../../Drivers/S2LP_Middleware/BlueNRG/src/: S2LP_CORE_GPIO.c S2LP_CORE_SPI.c
  group Source
    ../src/: BlueNRG1_it.c ST_Init.c
    ../../src/: main.c ST_Sigfox_Init.c
  group ST_Sigfox
    ../../../ST_API/src/: mcu_api_bluenrg1.c nvm_api.c rf_api.c
  group libs
    ../../../Sigfox_Libs/bin/: SFX_LIB_MON_CortexM0.a
    ../../../ST_API/bin/: ST_RETRIEVER_LIB_BLUENRG.a
target IDB008 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_IDB008 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH BLUENRG2_DEVICE FOR_ALL NO_BLE_STACK DEBUG_BLE_NO ERASE_VALUE_IS_FF IDB00xV2 USE_FLASH
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  link misc: --no_strict_wchar_size
target FKI001V1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: ST_SIGFOX_PB_FKI001V1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH FOR_ALL BLUENRG1_DEVICE NO_BLE_STACK DEBUG_BLE_NO ERASE_VALUE_IS_FF FKI001V1
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --no_strict_wchar_size
target MON_REF_DES (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: ST_SIGFOX_PB_MON_REF_DES +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH BLUENRG2_DEVICE FOR_ALL NO_BLE_STACK DEBUG_BLE_NO USE_FLASH ERASE_VALUE_IS_FF MON_REF_DES
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  link misc: --no_strict_wchar_size
software components: CMSIS:CORE 5.0.1
