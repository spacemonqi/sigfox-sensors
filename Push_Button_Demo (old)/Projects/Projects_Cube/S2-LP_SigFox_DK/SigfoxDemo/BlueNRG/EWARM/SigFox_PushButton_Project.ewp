# IAR project SigFox_PushButton_Project.ewp, settings and files
configuration IDB007 (ARM)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLUENRG1_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO; ERASE_VALUE_IS_FF; IDB00xV2; USE_FLASH
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Drivers\MCU\HAL_BLUENRG\inc; ..\..\..\..\..\Drivers\MCU\CMSIS\BlueNRG1\inc; ..\..\..\..\..\Drivers\MCU\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Drivers\BSP\SDK_Eval_BlueNRG\inc; ..\..\..\..\..\Drivers\S2LP_Middleware\BlueNRG\inc; ..\..\..\..\..\Drivers\Utils\BlueNRG\inc; ..\..\..\Sigfox_Libs\inc; ..\..\..\ST_API\inc; ..\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_IDB007.hex
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_IDB007.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Sigfox_Libs\bin\SFX_LIB_MON_CortexM0.a; ..\..\..\ST_API\bin\ST_RETRIEVER_LIB_BLUENRG.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IDB008 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLUENRG2_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO; ERASE_VALUE_IS_FF; IDB00xV2; USE_FLASH
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_IDB008.hex
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_IDB008.out
  ILINK.IlinkIcfFile: BlueNRG2.icf
configuration FKI001V1 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLUENRG1_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO; ERASE_VALUE_IS_FF; FKI001V1
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_FKI001V1.hex
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_FKI001V1.out
configuration MON_REF_DES (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLUENRG2_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO; USE_FLASH; ERASE_VALUE_IS_FF; MON_REF_DES
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_MON_REF_DES.hex
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_MON_REF_DES.out
  ILINK.IlinkIcfFile: BlueNRG2.icf
  group Drivers/BlueNRG_Drivers
    ../../../../../Drivers/MCU/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Drivers/BlueNRG_Drivers/HAL
    ../../../../../Drivers/MCU/HAL_BLUENRG/src/: clock.c context_switch.s gp_timer.c miscutil.c osal.c sleep.c
  group Drivers/BSP
    ../../../../../Drivers/BSP/SDK_Eval_BlueNRG/src/: SDK_EVAL_Button.c SDK_EVAL_Led.c
  group Drivers/CMSIS
    ../../../../../Drivers/MCU/CMSIS/BlueNRG1/src/: system_bluenrg1.c
  group Drivers/Utils
    ../../../../../Drivers/Utils/BlueNRG/src/: SDK_UTILS_Flash.c SDK_UTILS_Timers.c
  group S2LP_Middleware/S2LP_AUX
    ../../../../../Drivers/S2LP_Middleware/BlueNRG/src/: S2LP_AUX_EEPROM.c S2LP_AUX_Utils.c
    ../../../../../Drivers/S2LP_Middleware/BlueNRG/src/FEM/: S2LP_AUX_FEM_AUTO.c S2LP_AUX_FEM_MonarchRefDesign.c S2LP_AUX_FEM_NO.c
    ../../../../../Drivers/S2LP_Middleware/BlueNRG/src/TCXO/: S2LP_AUX_TCXO_AUTO.c S2LP_AUX_TCXO_NO.c
  group S2LP_Middleware/S2LP_CORE
    ../../../../../Drivers/S2LP_Middleware/BlueNRG/src/: S2LP_CORE_GPIO.c S2LP_CORE_SPI.c
  group Source
    ../src/: BlueNRG1_it.c ST_Init.c
    ../../src/: main.c ST_Sigfox_Init.c
  group ST_Sigfox
    ../../../ST_API/src/: mcu_api_bluenrg1.c nvm_api.c rf_api.c
