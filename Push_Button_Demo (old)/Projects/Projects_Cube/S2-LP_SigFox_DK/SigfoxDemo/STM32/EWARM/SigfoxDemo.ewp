# IAR project SigfoxDemo.ewp, settings and files
configuration NUCLEO_L0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; STM32L053xx
  ICCARM.CCIncludePath2: ..\inc; ..\..\inc; ..\..\..\Sigfox_Libs\inc; ..\..\..\ST_API\inc; ..\..\..\..\..\Drivers\BSP\SDK_Eval_STM32\inc; ..\..\..\..\..\Drivers\MCU\STM32_HAL\STM32L0xx_HAL_Driver\inc; ..\..\..\..\..\Drivers\MCU\CMSIS\STM32L0xx\inc; ..\..\..\..\..\Drivers\S2LP_Middleware\STM32\inc; ..\..\..\..\..\Drivers\Utils\STM32\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_NUCLEO_L0.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_NUCLEO_L0.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Sigfox_Libs\bin\SFX_LIB_MON_CortexM0+.a; ..\..\..\ST_API\bin\ST_RETRIEVER_LIB_CM0+.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NUCLEO_L1 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.CoreVariant: 38
  ICCARM.CCDefines: USE_STM32L1XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; STM32L152xE
  ICCARM.CCIncludePath2: ..\inc; ..\..\inc; ..\..\..\Sigfox_Libs\inc; ..\..\..\ST_API\inc; ..\..\..\..\..\Drivers\BSP\SDK_Eval_STM32\inc; ..\..\..\..\..\Drivers\MCU\STM32_HAL\STM32L1xx_HAL_Driver\inc; ..\..\..\..\..\Drivers\MCU\CMSIS\STM32L1xx\inc; ..\..\..\..\..\Drivers\S2LP_Middleware\STM32\inc; ..\..\..\..\..\Drivers\Utils\STM32\inc
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_NUCLEO_L1.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_NUCLEO_L1.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Sigfox_Libs\bin\SFX_LIB_MON_CortexM3.a; ..\..\..\ST_API\bin\ST_RETRIEVER_LIB_CM3.a
configuration NUCLEO_F0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.CoreVariant: 34
  ICCARM.CCDefines: USE_STM32F0XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; STM32F072xB; USE_HAL_LEGACY
  ICCARM.CCIncludePath2: ..\inc; ..\..\inc; ..\..\..\Sigfox_Libs\inc; ..\..\..\ST_API\inc; ..\..\..\..\..\Drivers\BSP\SDK_Eval_STM32\inc; ..\..\..\..\..\Drivers\MCU\STM32_HAL\STM32F0xx_HAL_Driver\inc; ..\..\..\..\..\Drivers\MCU\CMSIS\STM32F0xx\inc; ..\..\..\..\..\Drivers\S2LP_Middleware\STM32\inc; ..\..\..\..\..\Drivers\Utils\STM32\inc
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_NUCLEO_F0.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_NUCLEO_F0.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Sigfox_Libs\bin\SFX_LIB_MON_CortexM0.a; ..\..\..\ST_API\bin\ST_RETRIEVER_LIB_CM0.a
configuration NUCLEO_F4 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; ERASE_VALUE_IS_FF; STM32F401xE
  ICCARM.CCIncludePath2: ..\inc; ..\..\inc; ..\..\..\Sigfox_Libs\inc; ..\..\..\ST_API\inc; ..\..\..\..\..\Drivers\BSP\SDK_Eval_STM32\inc; ..\..\..\..\..\Drivers\MCU\STM32_HAL\STM32F4xx_HAL_Driver\inc; ..\..\..\..\..\Drivers\MCU\CMSIS\STM32F4xx\inc; ..\..\..\..\..\Drivers\S2LP_Middleware\STM32\inc; ..\..\..\..\..\Drivers\Utils\STM32\inc
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_NUCLEO_F4.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_NUCLEO_F4.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Sigfox_Libs\bin\SFX_LIB_MON_CortexM4.a; ..\..\..\ST_API\bin\ST_RETRIEVER_LIB_CM4.a
  group Drivers/BSP
    ../../../../../Drivers/BSP/SDK_Eval_STM32/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Led.c
  group Drivers/CMSIS/STM32F0xx
    ../../../../../Drivers/MCU/CMSIS/STM32F0xx/src/iar/: startup_stm32f072xb.s
    ../../../../../Drivers/MCU/CMSIS/STM32F0xx/src/: system_stm32f0xx.c
  group Drivers/CMSIS/STM32F4xx
    ../../../../../Drivers/MCU/CMSIS/STM32F4xx/src/iar/: startup_stm32f401xe.s
    ../../../../../Drivers/MCU/CMSIS/STM32F4xx/src/: system_stm32f4xx.c
  group Drivers/CMSIS/STM32L0xx
    ../../../../../Drivers/MCU/CMSIS/STM32L0xx/src/iar/: startup_stm32l053xx.s
    ../../../../../Drivers/MCU/CMSIS/STM32L0xx/src/: system_stm32l0xx.c
  group Drivers/CMSIS/STM32L1xx
    ../../../../../Drivers/MCU/CMSIS/STM32L1xx/src/iar/: startup_stm32l1xx_hd.s
    ../../../../../Drivers/MCU/CMSIS/STM32L1xx/src/: system_stm32l1xx.c
  group Drivers/HAL_Driver/STM32F0xx_HAL_Driver
    ../../../../../Drivers/MCU/STM32_HAL/STM32F0xx_HAL_Driver/src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Drivers/HAL_Driver/STM32F4xx_HAL_Driver
    ../../../../../Drivers/MCU/STM32_HAL/STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/HAL_Driver/STM32L0xx_HAL_Driver
    ../../../../../Drivers/MCU/STM32_HAL/STM32L0xx_HAL_Driver/src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/HAL_Driver/STM32L1xx_HAL_Driver
    ../../../../../Drivers/MCU/STM32_HAL/STM32L1xx_HAL_Driver/src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group Drivers/Utils
    ../../../../../Drivers/Utils/STM32/src/: SDK_UTILS_Flash.c SDK_UTILS_Timers.c
  group S2LP_Middleware/S2LP_AUX
    ../../../../../Drivers/S2LP_Middleware/STM32/src/: S2LP_AUX_EEPROM.c S2LP_AUX_UTILS.c
    ../../../../../Drivers/S2LP_Middleware/STM32/src/FEM/: S2LP_AUX_FEM_AUTO.c
    ../../../../../Drivers/S2LP_Middleware/STM32/src/TCXO/: S2LP_AUX_TCXO_AUTO.c
  group S2LP_Middleware/S2LP_CORE
    ../../../../../Drivers/S2LP_Middleware/STM32/src/: S2LP_CORE_GPIO.c S2LP_CORE_SPI.c
  group Source
    ../../src/: main.c ST_Sigfox_Init.c
    ../src/: ST_Init.c
  group Source/IrQ_Handler
    ../src/: stm32f0xx_it.c stm32f4xx_it.c stm32l0xx_it.c stm32l1xx_it.c
  group ST_Sigfox
    ../../../ST_API/src/: mcu_api_stm32.c nvm_api.c rf_api.c
