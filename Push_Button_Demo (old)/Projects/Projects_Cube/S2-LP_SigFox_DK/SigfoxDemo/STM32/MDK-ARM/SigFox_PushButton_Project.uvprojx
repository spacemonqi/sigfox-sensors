# Keil uVision project SigFox_PushButton_Project.uvprojx, settings and files
target NUCLEO_L0_ALL (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L053R8Hx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_NUCLEO_L0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32L0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY STM32L053xx
  c misc: --diag_suppress=951 --wchar32
  c include: ..\inc;..\..\inc;..\..\..\Sigfox_Libs\inc;..\..\..\ST_API\inc;..\..\..\..\..\Drivers\BSP\SDK_Eval_STM32\inc;..\..\..\..\..\Drivers\MCU\STM32_HAL\STM32L0xx_HAL_Driver\inc;..\..\..\..\..\Drivers\MCU\CMSIS\STM32L0xx\inc;..\..\..\..\..\Drivers\S2LP_Middleware\STM32\inc;..\..\..\..\..\Drivers\Utils\STM32\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\ST_SIGFOX_PB_NUCLEO_L0.sct
  link misc: --no_strict_wchar_size
  group Drivers\BSP
    ../../../../../Drivers/BSP/SDK_Eval_STM32/src/: SDK_EVAL_Button.c SDK_EVAL_Led.c
  group Drivers\CMSIS\STM32L0xx
    ../../../../../Drivers/MCU/CMSIS/STM32L0xx/src/: system_stm32l0xx.c
    ../../../../../Drivers/MCU/CMSIS/STM32L0xx/src/arm/: startup_stm32l053xx.s
  group Drivers\CMSIS\STM32L1xx
    ../../../../../Drivers/MCU/CMSIS/STM32L1xx/src/: system_stm32l1xx.c
    ../../../../../Drivers/MCU/CMSIS/STM32L1xx/src/arm/: startup_stm32l152xe.s
  group Drivers\CMSIS\STM32F0xx
    ../../../../../Drivers/MCU/CMSIS/STM32F0xx/src/: system_stm32f0xx.c
    ../../../../../Drivers/MCU/CMSIS/STM32F0xx/src/arm/: startup_stm32f072xb.s
  group Drivers\CMSIS\STM32F4xx
    ../../../../../Drivers/MCU/CMSIS/STM32F4xx/src/: system_stm32f4xx.c
    ../../../../../Drivers/MCU/CMSIS/STM32F4xx/src/arm/: startup_stm32f401xe.s
  group Drivers\HAL_Driver\STM32L0xx
    ../../../../../Drivers/MCU/STM32_HAL/STM32L0xx_HAL_Driver/src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers\HAL_Driver\STM32L1xx
    ../../../../../Drivers/MCU/STM32_HAL/STM32L1xx_HAL_Driver/src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group Drivers\HAL_Driver\STM32F0xx
    ../../../../../Drivers/MCU/STM32_HAL/STM32F0xx_HAL_Driver/src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Drivers\HAL_Driver\STM32F4xx
    ../../../../../Drivers/MCU/STM32_HAL/STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers\Utils
    ../../../../../Drivers/Utils/STM32/src/: SDK_UTILS_Flash.c SDK_UTILS_Timers.c
  group S2LP_Middleware\S2LP_AUX
    ../../../../../Drivers/S2LP_Middleware/STM32/src/: S2LP_AUX_EEPROM.c S2LP_AUX_UTILS.c
    ../../../../../Drivers/S2LP_Middleware/STM32/src/FEM/: S2LP_AUX_FEM_AUTO.c
    ../../../../../Drivers/S2LP_Middleware/STM32/src/TCXO/: S2LP_AUX_TCXO_AUTO.c
  group S2LP_Middleware\S2LP_CORE
    ../../../../../Drivers/S2LP_Middleware/STM32/src/: S2LP_CORE_GPIO.c S2LP_CORE_SPI.c
  group Source
    ../../src/: main.c ST_Sigfox_Init.c
    ../src/: ST_Init.c
  group Source\IrQ_Handler
    ../src/: stm32f0xx_it.c stm32f4xx_it.c stm32l0xx_it.c stm32l1xx_it.c
  group ST_Sigfox
    ../../../ST_API/src/: mcu_api_stm32.c nvm_api.c rf_api.c
  group libs
    ../../../Sigfox_Libs/bin/: ADDON_RF_PROTOCOL_MON_CortexM0.a ADDON_RF_PROTOCOL_MON_CortexM0+.a ADDON_RF_PROTOCOL_MON_CortexM3.a ADDON_RF_PROTOCOL_MON_CortexM4.a SFX_LIB_MON_CortexM0.a SFX_LIB_MON_CortexM0+.a SFX_LIB_MON_CortexM3.a SFX_LIB_MON_CortexM4.a
    ../../../ST_API/bin/: ST_RETRIEVER_LIB_CM0+.a ST_RETRIEVER_LIB_CM3.a ST_RETRIEVER_LIB_CM0.a ST_RETRIEVER_LIB_CM4.a
target NUCLEO_L1_ALL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_NUCLEO_L1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32L1XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY STM32L152xE
  c misc: --diag_suppress=951 --wchar32
  c include: ..\inc;..\..\inc;..\..\..\Sigfox_Libs\inc;..\..\..\ST_API\inc;..\..\..\..\..\Drivers\BSP\SDK_Eval_STM32\inc;..\..\..\..\..\Drivers\MCU\STM32_HAL\STM32L1xx_HAL_Driver\inc;..\..\..\..\..\Drivers\MCU\CMSIS\STM32L1xx\inc;..\..\..\..\..\Drivers\S2LP_Middleware\STM32\inc;..\..\..\..\..\Drivers\Utils\STM32\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  scatter file: .\ST_SIGFOX_PB_NUCLEO_L1.sct
  link misc: --no_strict_wchar_size
target NUCLEO_F0_ALL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_NUCLEO_F0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32F0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY STM32F072xB USE_HAL_LEGACY
  c misc: --diag_suppress=951 --wchar32
  c include: ..\inc;..\..\inc;..\..\..\Sigfox_Libs\inc;..\..\..\ST_API\inc;..\..\..\..\..\Drivers\BSP\SDK_Eval_STM32\inc;..\..\..\..\..\Drivers\MCU\STM32_HAL\STM32F0xx_HAL_Driver\inc;..\..\..\..\..\Drivers\MCU\CMSIS\STM32F0xx\inc;..\..\..\..\..\Drivers\S2LP_Middleware\STM32\inc;..\..\..\..\..\Drivers\Utils\STM32\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\ST_SIGFOX_PB_NUCLEO_F0.sct
  link misc: --no_strict_wchar_size
target NUCLEO_F4_ALL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_NUCLEO_F4 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32F4XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY ERASE_VALUE_IS_FF STM32F401xE
  c misc: --diag_suppress=951 --wchar32
  c include: ..\inc;..\..\inc;..\..\..\Sigfox_Libs\inc;..\..\..\ST_API\inc;..\..\..\..\..\Drivers\BSP\SDK_Eval_STM32\inc;..\..\..\..\..\Drivers\MCU\STM32_HAL\STM32F4xx_HAL_Driver\inc;..\..\..\..\..\Drivers\MCU\CMSIS\STM32F4xx\inc;..\..\..\..\..\Drivers\S2LP_Middleware\STM32\inc;..\..\..\..\..\Drivers\Utils\STM32\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\ST_SIGFOX_PB_NUCLEO_F4.sct
  link misc: --no_strict_wchar_size
software components: CMSIS:CORE 5.0.1
